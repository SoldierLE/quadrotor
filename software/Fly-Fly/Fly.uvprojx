# Keil uVision project Fly.uvprojx, settings and files
target Fly (ARM-ADS)
  device: STM32F373CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fly +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F37X
  c include: .\APP;.\BSP;.\Doc;.\Libraries\STM32F373xx_StdPeriph_Driver\inc;.\Libraries\STM32F373xx_StdPeriph_Driver\src;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\DeviceSupport\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./APP/: main.c stm32f37x_it.c
  group BSP
    ./BSP/: GPIO.c Sys.c PWM.c ADC.c UART.c I2C.c mpu6500.c MotoCtrl.c
  group CMSIS
    ./Libraries/CMSIS/DeviceSupport/: system_stm32f37x.c
  group STARTUP CODE
    ./Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f37x.s
  group STM32F3XX_stdperiph_Driver
    ./Libraries/STM32F373xx_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
